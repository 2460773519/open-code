# Keil uVision project zf_rtt_demo.uvprojx, settings and files
target ZF_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zf_rtt_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CODE;..\USER\src;..\USER\inc;..\Libraries\seekfree_libraries\common;..\Libraries\seekfree_libraries\board;..\Libraries\seekfree_libraries;..\Libraries\seekfree_peripheral;..\Libraries\Device\CMSIS\KEIL_Core;..\Libraries\Device\MM32F327x\Include;..\Libraries\Device\MM32F327x\HAL_Lib\Inc;..\Libraries\rtthread_libraries\bsp;..\Libraries\rtthread_libraries\components\finsh;..\Libraries\rtthread_libraries\include;..\Libraries\rtthread_libraries\include\libc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/src/: isr.c main.c
    ../Libraries/rtthread_libraries/bsp/: rtconfig.h
    ../USER/: uart2.c uart3.c
  group board
    ../Libraries/seekfree_libraries/board/: board.c
  group common
    ../Libraries/seekfree_libraries/common/: common.c SEEKFREE_ASSERT.c SEEKFREE_FUN.c SEEKFREE_PRINTF.c
  group startup
    ../Libraries/Device/MM32F327x/Source/: system_mm32f327x.c
    ../Libraries/Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group doc
    ../Libraries/doc/: pin_recommend.txt version.txt
  group seekfree_libraries
    ../Libraries/seekfree_libraries/: zf_adc.c zf_camera.c zf_exti.c zf_flash.c zf_fsmc.c zf_gpio.c zf_pit.c zf_pwm.c zf_spi.c zf_systick.c zf_tim.c zf_uart.c
  group seekfree_peripheral
    ../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_7725.c SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_FONT.c SEEKFREE_ICM20602.c SEEKFREE_IIC.c SEEKFREE_IPS114_SPI.c SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_L3G4200D.c SEEKFREE_MMA8451.c SEEKFREE_MPU6050.c SEEKFREE_MT9V03X.c SEEKFREE_OLED.c SEEKFREE_TSL1401.c SEEKFREE_UART_7725.c SEEKFREE_VIRSCO.c SEEKFREE_WIRELESS.c
  group MM32_HAL
    ../Libraries/Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group rtt_src
    ../Libraries/rtthread_libraries/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt_inc
    ../Libraries/rtthread_libraries/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
    ../Libraries/rtthread_libraries/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_signal.h libc_stat.h
  group rtt_lib
    ../Libraries/rtthread_libraries/libcpu/: context_rvds.S cpuport.c
  group rtt_componer
    ../Libraries/rtthread_libraries/components/finsh/: cmd.c finsh.h finsh_api.h msh.c msh.h shell.c shell.h
